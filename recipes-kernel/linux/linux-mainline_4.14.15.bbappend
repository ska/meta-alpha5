
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://0001-add-dwmac-sun8i-driver.patch \
             file://0002-Added-Wifi-driver-for-xradio-X819.patch \
"
